# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\include;..\..\..\Menu\inc;..\HARDWARE\cTask;..\HARDWARE\Key\inc;..\HARDWARE\OLED\inc;..\HMI\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c user_config.h
  group SYSTEM
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/usart/: usart.c usart.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_crc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
  group HARDWARE
    ../HARDWARE/src/: timer.c
  group OLED
    ../HARDWARE/OLED/src/: oled.c oledconf.c oledio.c
  group cTask
    ../HARDWARE/cTask/: cTask.c
  group KEY
    ../HARDWARE/Key/src/: key.c keyio.c
  group Menu
    ../../../Menu/src/: menu.c
  group HMI
    ../HMI/src/: hmi_camera.c hmi_more_set.c hmi_music.c hmi_set.c hmi_video.c mainhmi.c
